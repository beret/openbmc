
SRC_URI = "git://github.com/beret/entity-manager;protocol=https;branch=mc12-le0 file://blocklist.json"
SRCREV = "634c26104b72fa5f863e09156404ae0e9068b68f"
